# Keil uVision project main.uvprojx, settings and files
target HQU_Cheng (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: .\Driver;.\RTE;.\User;.\uC-CPU;.\uC-CPU\ARM-Cortex-M3\RealView;.\uC-LIB;.\uC-LIB\Ports\ARM-Cortex-M3\RealView;.\APP;.\BSP;.\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;.\uCOS-III\Ports;.\uCOS-III\Source;.\uCOS-III
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Urser
    ./User/: config.h config.cpp User_main.c
  group Funtion
    ./Driver/: system.h gpio.h oled.h EXTI.h uart.h dma.h stm32f10x_it.h iic_cs.h adc.h tim.h dac.h spi.h flash.h ILI9341_LCD.h OV7725.h ESP8266.h Common_Function.h W25Q64.h iic_ee.h PID.h
  group APP
    ./APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_cfg_app.h os_app_hooks.h os_cfg.h
  group uC/OS-III Source
    ./uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group BSP
    ./BSP/: bsp.c bsp.h
  group Driver
    ./Driver/: system.c gpio.cpp EXTI.cpp uart.cpp dma.cpp oled.cpp stm32f10x_it .cpp iic_cs.cpp adc.cpp tim.cpp dac.cpp spi.cpp flash.cpp ILI9341_LCD.cpp OV7725.cpp ESP8266.cpp Common_Function.cpp W25Q64.cpp iic_ee.cpp PID.c
  group uC/CPU
    ./uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ./uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ./uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ./uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Port
    ./uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group 目录
    ./目录/: uCOS-III说明.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
